# Keil uVision project SuperSanity.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SuperSanity +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Drivers\boards\api;..\Drivers\boards\sanity-v1708;..\Drivers\nRF24L01;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Drivers\MPU6050;..\Drivers\Debug;..\uCOS-II\Source;..\uCOS-II\Ports;..\Drivers\Motor;..\Drivers\MS5611;..\Drivers\Sensors;..\modules;..\modules\estimate_control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group STM32F1xx_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../User/: main.c stm32f10x_it.c app_cfg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group BoardDrivers
    ../Drivers/nRF24L01/: nRF24L01.c
    ../Drivers/boards/sanity-v1708/: board_config.c
    ../Drivers/Debug/: debug.c
    ../Drivers/Motor/: motor.c
    ../Drivers/boards/api/: api_spi.c api_i2c.c api_i2c2.c
    ../Drivers/Sensors/: sensors.c
    ../Drivers/MS5611/: ms5611_s.c
    ../Drivers/MPU6050/: mpu6050_s.c
  group Ports
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group modules
    ../modules/: attitude_control.c attitude_estimate.c
